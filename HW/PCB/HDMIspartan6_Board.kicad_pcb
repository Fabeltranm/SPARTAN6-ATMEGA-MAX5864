# Repository Fabeltranm/SPARTAN6-ATMEGA-MAX5864 (continued)

## KiCad design hard/hw/Basic_pcb/HDMIspartan6_Board.kicad_pcb (continued)

Parts:
C6, C7: 10u; C_0805
C8, C10: 10u; C_0603
C9: 100n; C_0402
C11, C12, C13: 22u; C_0805
CF1, CF2, CF3, CF4, CF5, CF6, CF7, CF8, CF9, CF10, CF12, CF14, CF15, CF16, CF17, CF18, CF19, CF20, CF21, CF22, CF23, CF24, CF25: 0.1uF; SM0603
CF11, CF26, CF27: 1uF; SM0603
CF13, CF28, CF29: 4.7uF; SM1206_Opendous
CF30, CF32, CF33, CF35: 33uF; SM1206_Opendous
CF31, CF34: 100n; SM0603
L3: XFL4020-152ME; XFL4020
P3, P4: CONN_02X02; Socket_Strip_Straight_2x02_Pitch2.54mm
P6: CONN_01X03; Socket_Strip_Straight_1x03_Pitch2.54mm
P7: B6B-PH-K-S(LF)(SN); JST_PH_B6B-PH-K_06x2.00mm_Straight
PS1: BARREL_JACK; JACK_ALIM
R12: 10k; R_0603
R13: 680k; R_0603
R14: 130k; R_0603
R15: 100k; R_0603
S1: 9077-1; CKCOMP-OS102011MA1QN1
U2: TPS63070; TPS63071; DIGIKEY REF TPS63070RNMR
UF2: ZLDO1117G33TA; SOT-223; DIGIKEY REF ZLDO1117G33DITR-ND
UF3: ZLDO1117G12TA; SOT-223; DIGIKEY REF ZLDO1117G12DITR-ND

Connections:
+1V2: CF16.1, CF18.1, CF19.1, CF22.1, CF24.1, CF26.1, CF28.1, CF34.1, CF35.1, UF3.2 (OUT), UF3.4 (OUTT); also elsewhere on the board
+5V: CF30.1, P3.2, P4.2, P6.2, UF2.3 (IN); also elsewhere on the board
+9V: PS1.1, S1.1 (S)
/Power/+9V0: C6.1, C7.1, C8.1, P7.5, P7.6, R12.1, S1.2, U2.12 (Vin), U2.13 (Vin)
/Power/USBVCC: P6.3; also elsewhere on the board
GND: C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, CF1.2, CF2.2, CF3.2, CF4.2, CF5.2, CF6.2, CF7.2, CF8.2, CF9.2, CF10.2, CF11.2, CF12.2, CF13.2, CF14.2, CF15.2, CF16.2, CF17.2, CF18.2, CF19.2, CF20.2, CF21.2, CF22.2, CF23.2, CF24.2, CF25.2, CF26.2, CF27.2, CF28.2, CF29.2, CF30.2, CF31.2, CF32.2, CF33.2, CF34.2, CF35.2, P3.3, P3.4, P4.3, P4.4, P7.1, P7.2, PS1.2, R14.2, U2.4 (Gnd), U2.6 (Fb2), U2.10 (PGnd), U2.15 (Vsel), UF2.1 (GND), UF3.1 (GND); also elsewhere on the board
unnamed: C9.1, U2.3 (Vaux)
unnamed: L3.1, U2.11 (L1)
unnamed: L3.2, U2.9 (L2)
unnamed: R12.2, U2.1 (PS/Sync), U2.14 (Enable)
unnamed: R13.2, R14.1, U2.5 (Fb)
unnamed: R15.2, U2.2 (PG)
VDD5V: C10.1, C11.1, C12.1, C13.1, P6.1, P7.4, R13.1, R15.1, U2.7 (Vout), U2.8 (Vout)

Notes on the sheet:
Conector para seleccionar fuente por medio de un jumper. > VDD5V: Fuente jack DC de 9VDC a 5VDC. > +5V: Referencia de 5VDC de toda la tarjeta. > USBVCC: 5VDC obtenido por conector USB

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
Board: 4 copper layers, 167 parts (62 on the bottom side), 111 nets, no tracks yet.

Other parts of the board:
PIO2: CONN_02X10; Socket_Strip_Straight_2x10_Pitch2.54mm

Their connections:
+5V: PIO2.1; also elsewhere on the board
GND: PIO2.4; also elsewhere on the board

## KiCad design hard/others/fuente 12 a 5 A/fuente.kicad_pcb

Board: 2 copper layers, 30.3 x 20.1 mm, 12 parts (0 on the bottom side), 8 nets.

Parts:
C1: 10u; SM0805
C2: 10 u; SM0805
C3, C5: 10u; SM0603
C4: 100n; SM0603
C6, C7, C8: 22u; SM0805
L1: INDUCTOR; XFL4020
R1: 10k; SM0603
R2: R; SM0603
U1: TPS63071

Connections:
+5V: C5.1, C6.1, C7.1, C8.1, R2.1, U1.5, U1.7, U1.8
+12V: C1.1, C2.1, C3.1, R1.1, U1.12, U1.13
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, U1.4, U1.6, U1.10, U1.15
unnamed: R2.2, U1.2
unnamed: L1.1, U1.11
unnamed: L1.2, U1.9
unnamed: C4.1, U1.3
unnamed: R1.2, U1.1, U1.14

## Commit log

2017-01-23 init
2017-01-31 Create bas
2017-02-02 version0.0
2017-02-02 deleted
    Please enter the commit message for your changes. Lines starting
2017-02-06 nuevo nombre
2017-02-06 Agregando nuevas hojas jerarquicas
    Hojas agregadas: Power y Audio
2017-02-06 Bloque de Audio
    Bloque de Audio implementado PAM8302 de adafruit:
    https://www.adafruit.com/product/2130
2017-02-06 Actualizacion Power
2017-02-06 Power: fuente de 5v - 2A
    by Luis Yaya
2017-02-07 ok 3d
2017-02-07 Actualizaciòn vista 3D
2017-02-08 Fuente 12V
    by Luis Yaya
2017-02-08 Actualización PinOut LVDS
    by Rubén Parra
2017-02-09 Datasheets
    By Rubén
2017-02-09 Actualizacion Raiz
    por Rubén
2017-02-10 Actualización Raiz
    by Rubén
2017-02-14 Actualizacion ref. DigitKey
    by Rubén
2017-02-14 Actualización SDRAM
2017-02-14 Actualización huellas y fusible
    by Rubén
2017-02-15 todas las huellas
    by Ruben
2017-02-16 Organizando PIN OUT vr.:0.1
    by Ruben
2017-02-17 Shields: Clamp-header
    Modificacion diametro de orificio pasante para tornillo 1/8
2017-02-20 Terminado Shield
    by Ruben
2017-02-20 Actualizacion Datasheet
2017-02-22 shield corregido
2017-02-22 shield 2.0
2017-02-27 Alimentacion Pantalla
2017-02-27 Clamp gerber update
2017-02-27 Todos los componentes en la tarjeta
    by Ruben
2017-02-28 Correccion Shield Clamp
    by Ruben
2017-03-03 LVDS ultimate test
    by LUIS
2017-03-04 Update board
    by Ruben
2017-03-09 Actualización K3
    by Ruben
2017-03-14 ProgRpiI2C
2017-03-14 Datasheets
2017-03-14 Revert "Datasheets"
    This reverts commit edbb8b8abfee325c3b920922dc11246233119ce4.
2017-03-14 Datasheet
2017-03-15 Revert "Revert "Datasheets""
    This reverts commit cc850c74b615b4119cf9ee2c458186102debd915.
2017-03-16 Revert "Revert "Revert "Datasheets"""
    This reverts commit 8b7c1ae5629daf9b9925dc53a42c9cad6393ae71.
2017-03-23 v1.0
2017-03-23 .gitignore
2017-05-18 Add ADC
2017-05-19 librarys
2017-05-30 Update supply power
2017-05-30 update 29 MAY
2017-05-30 Corrección esquematico
2017-05-30 Correccion SCH
2017-05-30 update TODO
2017-05-31 2x40 .
2017-05-31 2xx40 conn
2017-05-31 Add 3d model
2017-05-31 update 3d models
2017-06-01 reorganización
2017-06-05 update layout
2017-06-05 Test LVDS RAM
2017-06-05 Add jmp Rpi Power
2017-06-06 config power
2017-07-08 se modifican el pin hdmi- las resitencias RN1 - eñ conector de voltaje
2017-07-10 cambios en el pinout para HDMI-LVDS tarjeta HDMI Spartan6
2017-07-10 archivo de prueba
2017-07-13 cambios para que fuencione la pantalla de 18 bits
2017-07-13 ajustes para configuracion de la pantalla 13.3"
2017-07-17 cambios en el pinout de la FPGA para uso del puerto HDMI
2017-08-01 ok lvds and hdmi
2017-09-21 Changes in HDMISpartan6_Board
2017-09-28 versión 1.0
2017-09-28 v1-0
2017-09-29 version1.oo1
2017-09-30 add gerber files
2017-10-06 versión final
2017-10-06 all connected
2017-10-13 silkS progresing
2017-10-23 SilkS 2
2017-10-23 SilkS 2.1
2017-10-24 cambio de la memoria flash, referecnia y encapsulado
2017-10-25 conexión de la memoria flash y verificación del plano de tierras
2018-07-03 nueva Tarjeta
2018-08-04 change all board files
2018-11-15 se cambia la referencia del resonador XF2, queda pendiente actualizar la huella
2018-11-15 add file
2018-11-16 modificardo cF7 y cF8 a 33 pf
2018-12-04 error array resistencia hdm footprint 1206 error ...se debe cambiar
2019-02-05 add Docs
2019-02-06 docs img pinout
2019-02-28 add pinout P! imagen
2019-02-28 add readme
2019-02-28 add readme1
2019-03-04 add esquema
2019-08-12 add ejemplos
2019-08-12 add labs
2019-08-12 add primi
2019-08-19 sum4b
2019-08-19 add s
2019-08-20 test
2019-08-20 test2
2019-08-21 mapeo
2019-08-21 c mapeo
2019-08-21 add map
2019-08-21 add presentaciones
2019-08-21 add basys2
2019-08-21 add sum4b
2019-08-21 add nu
2019-08-21 add ise
2019-08-26 add ejemplo03
2019-08-28 ok lb3
2019-09-10 ADD A,B,C
2019-09-15 add
    add ej 4 3
2019-09-15 aa
    a
2019-10-17 add
    add ej7
2019-10-18 lb08
    0
2019-10-18 lab08
2019-10-23 lb9
    l9
