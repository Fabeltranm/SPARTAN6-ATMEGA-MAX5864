# Repository Fabeltranm/SPARTAN6-ATMEGA-MAX5864 (continued)

## KiCad design HW/PCB/HDMIspartan6_Board.kicad_pcb (continued)

Parts:
C43: 4.7uF; C_0805; DIGIKEY REF Ceramic X5R ESR < 60mOhm
C44, C47, C48, C49: 1uF; C_0402; DIGIKEY REF Ceramic X5R ESR < 60mOhm
C45: 10nF; C_0603
C46: 10uF; C_0603
CF7, CF8: 47pF; C_0603
JMS2: USB-MINI; USB_Mini-B; DIGIKEY REF ED2992TR-ND
L2: HZ0805D152R-10; R_0805_HandSoldering; DIGIKEY REF 240-2398-1-ND
P5: CONN_02X05; Pin_Header_Straight_2x05_Pitch2.54mm
R14, R15: 2k2; R_0603
RF9, RF10: 27R; R_0603
RM1: 10k; R_0603
U7: ATMEGA32U4-A; LQFP-44_10x10mm_Pitch0.8mm; DIGIKEY REF ATMEGA32U4-AURCT-ND
XF2: CSTNE8M00G55Z000R0; CSTCE8M00G55-RO; DIGIKEY REF 490-17960-1-ND

Connections:
+3V3: C43.1, C44.1, C45.1, C47.1, L2.1, P5.1, R14.2, R15.1, RM1.2, U7.6 (UCAP), U7.14 (VCC), U7.34 (VCC); also elsewhere on the board
/atmega32u4/ADC0: P5.3, U7.41 ((ADC0)PF0)
/atmega32u4/ADC1: P5.4, U7.40 ((ADC1)PF1)
/atmega32u4/ADC4: P5.5, U7.39 ((ADC4/TCK)PF4)
/atmega32u4/ADC5: P5.6, U7.38 ((ADC5/TMS)PF5)
/atmega32u4/ADC6: P5.7, U7.37 ((ADC6/TDO)PF6)
/atmega32u4/ADC7: P5.8, U7.36 ((ADC7/TDI)PF7)
/atmega32u4/ADC11: P5.10, U7.28 ((ADC11/PCINT4)PB4)
/atmega32u4/ADC12: P5.9, U7.29 ((ADC12/OC1A/~OC4B~/PCINT12)PB5)
/atmega32u4/VBUS: C49.1, JMS2.1 (VBUS), U7.2 (UVCC), U7.7 (VBUS)
/atmega32u4/rst_um: RM1.1, U7.13 (~RESET~); also elsewhere on the board
/atmega32u4/uD0: R14.1, U7.18 ((OC0B/SCL/INT0)PD0); also elsewhere on the board
/atmega32u4/uD1: R15.2, U7.19 ((SDA/INT1)PD1); also elsewhere on the board
/atmega32u4/uD2: U7.20 ((RXD/INT2)PD2); also elsewhere on the board
/atmega32u4/uD3: U7.21 ((TXD/INT3)PD3); also elsewhere on the board
/atmega32u4/uD4: U7.25 ((ICP2/ADC8)PD4)
/atmega32u4/uD5: U7.22 ((XCK1/~CTS~)PD5)
/atmega32u4/uD6: U7.26 ((T1/~OC4D~/ADC9)PD6)
/atmega32u4/uD8: U7.30 ((ADC13/OC1B/OC4B/PCINT13)PB6)
/atmega32u4/uDONE: U7.1 ((INT6/AIN0)PE6); also elsewhere on the board
/atmega32u4/uINIT_B: U7.32 ((ICP3/CLK0/OC4A)PC7); also elsewhere on the board
/atmega32u4/uMISO: U7.11 ((PDO/MISO/PCINT3)PB3); also elsewhere on the board
/atmega32u4/uP0: U7.8 ((SS/PCINT0)PB0); also elsewhere on the board
/atmega32u4/uP1: U7.9 ((SCLK/PCINT1)PB1); also elsewhere on the board
/atmega32u4/uP5: U7.31 ((OC3A/~OC4A~)PC6); also elsewhere on the board
/spartan6/LED2: U7.27 ((T0/OC4D/ADC10)PD7); also elsewhere on the board
/spartan6/uM0SI: U7.10 ((PDI/MOSI/PCINT2)PB2); also elsewhere on the board
GND: C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, CF7.1, CF8.1, JMS2.5 (GND), JMS2.6 (SH), JMS2.7 (SH), JMS2.8 (SH), JMS2.9 (SH), P5.2, U7.5 (UGND), U7.15 (GND), U7.23 (GND), U7.33 ((~HWB~)PE2), U7.35 (GND), U7.43 (GND), XF2.2 (GND); also elsewhere on the board
unnamed: C46.1, L2.2, U7.24 (AVCC), U7.44 (AVCC)
unnamed: C48.1, U7.42 (AREF)
unnamed: CF7.2, U7.17 (XTAL1), XF2.1
unnamed: CF8.2, U7.16 (XTAL2), XF2.3
unnamed: JMS2.2 (D-), RF9.1
unnamed: JMS2.3 (D+), RF10.1
unnamed: RF9.2, U7.3 (D-)
unnamed: RF10.2, U7.4 (D+)

Notes on the sheet:
micro decoupling
I2C: SCL
I2C: SDA
NOTA: PARA PROGRAMAR LA FPGA DESDE EL MICRO, SE DEBE TENER EN CUENTA QUE NO SE USA DIRECTAMENTE EL HW SPI Y ESTE SE DEBE HACER POR SOFTWARE ACORDE A LA FIGURA 2-3 DEL LA REFERENCIA UG380 (v2.10) March 31, 2017 DE XILINX
UART: RX
UART: TX
NOTA: CAMBIAR LA HUELLA DEL RESONADOR XF2

Board: 2 copper layers, 99.0 x 58.5 mm, 255 parts (70 on the bottom side), 161 nets.

Other parts of the board:
J4: CONN-MICRO-SD-CARD-PUSH-PULL; CONN-SD-MICRO-MOLEX_2

Their connections:
+3V3: J4.4; also elsewhere on the board
/spartan6/usCS: J4.2; also elsewhere on the board
/spartan6/usMISO: J4.7; also elsewhere on the board
/spartan6/usMOSI: J4.3; also elsewhere on the board
/spartan6/usSCK: J4.5; also elsewhere on the board
GND: J4.6; also elsewhere on the board

## KiCad design hard/hw/Basic_pcb/HDMIspartan6_Board.kicad_pcb

File hard/README.md:

# READ TODO.md
## Last update 27/05

Parts:
TH1, TH2, TH3, TH4, TH5, TH6, TH7, TH8, TH9, TH10, TH11, TH12, TH13, TH14, TH15, TH16, TH17, TH18, TH19, TH20, TH21, TH22, TH23, TH24, TH25, TH26, TH27, TH28, TH29, TH30, TH31, TH32, TH33, TH34, TH35, TH36, TH37, TH38, TH39, TH40, TH41, TH42, TH43, TH44, TH45, TH46, TH47, TH48, TH49, TH50: CONN_1; 1Pin_12mil_VIA

Connections:
GND: TH1.1, TH2.1, TH3.1, TH4.1, TH5.1, TH6.1, TH7.1, TH8.1, TH9.1, TH10.1, TH11.1, TH12.1, TH13.1, TH14.1, TH15.1, TH16.1, TH17.1, TH18.1, TH19.1, TH20.1, TH21.1, TH22.1, TH23.1, TH24.1, TH25.1, TH26.1, TH27.1, TH28.1, TH29.1, TH30.1, TH31.1, TH32.1, TH33.1, TH34.1, TH35.1, TH36.1, TH37.1, TH38.1, TH39.1, TH40.1, TH41.1, TH42.1, TH43.1, TH44.1, TH45.1, TH46.1, TH47.1, TH48.1, TH49.1, TH50.1; also elsewhere on the board

Notes on the sheet:
PENDIENTES: >>> IMPLEMENTAR REGLAS DEL FABRICANTE <<< - Reorganizar PinOut - Asignar LEDs indicadores a FPGA DUDAS: - El pin ~SD~ del amplificador de sonido PAM8302 esta conectado desde la FPGA para habilitar el sonido, pero tambien a una regleta para poder activilarlo con un jumper ¿se requiere al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

Parts:
CF36: 10nF; SM0603_Opendous
CF37: 10uF; SM1210_Opendous
CF38: 100nF; SM0603_Opendous
CF39: 33nF; SM0603_Opendous
CF40, CF41: 47pF; SM0603_Opendous
F1: PTS08056V050; R_1812
FT1: FT2232D-REEL; LQFP-48_7x7mm_Pitch0.5mm; DIGIKEY REF 768-1010-1-ND
JMS1: USB-MINI; USB_Mini-B
LF11: HZ0805D152R-10; SM0805
RF14, RF15: 27R; SM0603_Opendous
RF16: 10K; SM0603_Opendous
RF17: 1K5; SM0603_Opendous
RF18: 470R; SM0603_Opendous
RF19, RF20: 10k; SM0603_Opendous
RF21: 15K; SM0603_Opendous
XF2: 6MHz; CSTCR6M00G53Z; DIGIKEY REF 490-1218-2-ND

Connections:
/Power/USBVCC: CF36.1, F1.1, LF11.1; also elsewhere on the board
/serial_interface/+5VA: CF37.1, FT1.3 (VCC0), FT1.4 (RESET#), FT1.42 (VCC1), LF11.2, RF16.1, RF18.2
/spartan6/F_RXD: FT1.39 (BDBUS1), RF21.2; also elsewhere on the board
/spartan6/F_TCK: FT1.24 (ADBUS0); also elsewhere on the board
/spartan6/F_TDI: FT1.23 (ADBUS1); also elsewhere on the board
/spartan6/F_TDO: FT1.22 (ADBUS2); also elsewhere on the board
/spartan6/F_TMS: FT1.21 (ADBUS3); also elsewhere on the board
/spartan6/F_TXD: FT1.40 (BDBUS0); also elsewhere on the board
GND: CF36.2, CF37.2, CF38.2, CF39.2, CF40.1, CF41.1, FT1.9 (GND0), FT1.18 (GND1), FT1.25 (GND2), FT1.34 (GND3), FT1.45 (AGND), FT1.47 (TEST), JMS1.5 (GND), JMS1.6 (SH), JMS1.7 (SH), JMS1.8 (SH), JMS1.9 (SH), XF2.2 (GND), XF2.4 (GND); also elsewhere on the board
unnamed: CF38.1, FT1.46 (AVVC), RF18.1
unnamed: CF39.1, FT1.6 (3V3OUT)
unnamed: CF40.2, FT1.43 (XTIN), XF2.1
unnamed: CF41.2, FT1.44 (XTOUT), XF2.3
unnamed: F1.2, JMS1.1 (VBUS)
unnamed: FT1.2 (EEDATA), RF16.2
unnamed: FT1.5 (RSTOUT#), RF17.2
unnamed: FT1.7 (USBDP), RF15.2, RF17.1
unnamed: FT1.8 (USBDM), RF14.2
unnamed: FT1.10 (SI/WUA), RF19.1
unnamed: FT1.26 (SI/WUB), RF20.1
unnamed: JMS1.2 (D-), RF14.1
unnamed: JMS1.3 (D+), RF15.1

Notes on the sheet:
ED2992TR-ND

Parts:
C1: 10uF; C_0805
C2, C3: 1uF; C_0805
C4, C5: 220pF; C_0805
L1, L2: Ferrite_Bead; R_0805
P1: CONN_01X03; Socket_Strip_Straight_1x03_Pitch1.27mm
P2: CONN_01X02; Socket_Strip_Straight_1x02_Pitch2.54mm
P5: CONN_01X03; Socket_Strip_Straight_1x03_Pitch2.54mm
R1: 10k; R_0805
R2, R3: 100; R_0805
RV1: 10K POT_TRIM; Potentiometer_Trimmer-EVM3E
U1: PAM8302AASCR; MSOP-8_3x3mm_Pitch0.65mm; DIGIKEY REF PAM8302AASCRDI-ND

Connections:
+5V: C1.1, P5.1, R1.2, U1.6 (VDD); also elsewhere on the board
/Audio/AIN+: P1.1, RV1.1
/Audio/AIN-: C3.2, P1.2, RV1.3
/spartan6/F_~SD: P5.2, R1.1, U1.1 (~SD); also elsewhere on the board
GND: C1.2, C4.1, C5.1, P1.3, P5.3, U1.7 (GND); also elsewhere on the board
unnamed: C2.1, R2.2
unnamed: C2.2, RV1.2
unnamed: C3.1, R3.2
unnamed: C4.2, L1.2, P2.1
unnamed: C5.2, L2.2, P2.2
unnamed: L1.1, U1.8 (VO-)
unnamed: L2.1, U1.5 (VO+)
unnamed: R2.1, U1.3 (IN+)
unnamed: R3.1, U1.4 (IN-)

Parts:
DF1, DF2: LED; SM0603
IC1: W9812G6KH; TSOPII54_SDRAM_MT48; DIGIKEY REF W9812G6KH-6 TR-ND
J1: HDMI_A; FCI_10029449-11[13]RLF; DIGIKEY REF 10029449-113RLF-ND
LVDS1: CONN_02X15; Pin_Header_Straight_2x15_Pitch2.00mm
PIO1: CONN_02X20; Socket_Strip_Straight_2x20_Pitch2.54mm
R4, R5, R6, R7, R8, R9, R10, R11: 51; R_0805
RF1: 47k; SM0603
RF2: 4.7k; SM0603
RF3, RF4, RF6, RF7: 68; SM0603
RF5, RF8: 1k; SM0603
SW1: B3SL-1002P; SW_SPST_B3SL-1002P
UF1: XC6SLX9-2TQG144C; LQFP-144_20x20mm_Pitch0.5mm; DIGIKEY REF 122-1745-ND
X1: ASV-32.000MHZ-E-T; OSCILLATOR_7x5mm; DIGIKEY REF 535-10082-2-ND

Connections:
+1V2: UF1.19 (VCCINT), UF1.28 (VCCINT), UF1.52 (VCCINT), UF1.89 (VCCINT), UF1.128 (VCCINT); also elsewhere on the board
/spartan6/A0: IC1.23 (A0), UF1.140 (IO_L3P_0)
/spartan6/A1: IC1.24 (A1), UF1.139 (IO_L3N_0)
/spartan6/A2: IC1.25 (A2), UF1.138 (IO_LP_0)
/spartan6/A3: IC1.26 (A3), UF1.137 (IO_L4N_0)
/spartan6/A4: IC1.29 (A4), UF1.46 (IO_L49P_D3_2)
/spartan6/A5: IC1.30 (A5), UF1.45 (IO_L49N_D4_2)
/spartan6/A6: IC1.31 (A6), UF1.44 (IO_L62P_D5_2)
/spartan6/A7: IC1.32 (A7), UF1.43 (IO_L62N_D6_2)
/spartan6/A8: IC1.33 (A8), UF1.41 (IO_L64P_D8_2)
/spartan6/A9: IC1.34 (A9), UF1.40 (IO_L64N_D9_2)
/spartan6/A10: IC1.22 (A10), UF1.141 (IO_L2N_0)
/spartan6/A11: IC1.35 (A11), UF1.35 (IO_L1P)
/spartan6/BA0: IC1.20 (BA0), UF1.143 (IO_L1N_VREF_0)
/spartan6/BA1: IC1.21 (BA1), UF1.142 (IO_L2P_0)
/spartan6/CH1N: LVDS1.7, UF1.50 (IO_L31N_GCLK30_D15_2)
/spartan6/CH1P: LVDS1.8, UF1.51 (IO_L31P_GCLK31_D14_2)
/spartan6/CH2N: LVDS1.9, UF1.55 (IO_L30N_GCLK0_USERCCLK_2)
/spartan6/CH2P: LVDS1.10, UF1.56 (IO_L30P_GCLK1_D13_2)
/spartan6/CH3N: LVDS1.11, UF1.57 (IO_L14N_D12_2)
/spartan6/CH3P: LVDS1.12, UF1.58 (IO_L14P_D11_2)
/spartan6/CH4N: LVDS1.17, UF1.64 (IO_L3N_MOSI_CSI_B_MISO0_2)
/spartan6/CH4P: LVDS1.18, UF1.65 (IO_L3P_D0_DIN_MISO_MISO1_2)
/spartan6/CKE: IC1.37 (CKE), UF1.33 (IO_L2P_3)
/spartan6/CLK: IC1.38 (CLK), UF1.32 (IO_L2N_3)
/spartan6/CLKN: LVDS1.15, UF1.61 (IO_L12N_D2_MISO3_2)
/spartan6/CLKP: LVDS1.16, UF1.62 (IO_L12P_D1_MISO2_2)
/spartan6/DQ0: IC1.2 (DQ0), UF1.9 (IO_L50N_3)
/spartan6/DQ1: IC1.4 (DQ1), UF1.10 (IO_L50P_3)
/spartan6/DQ2: IC1.5 (DQ2), UF1.11 (IO_L49N_3)
/spartan6/DQ3: IC1.7 (DQ3), UF1.12 (IO_L49P_3)
/spartan6/DQ4: IC1.8 (DQ4), UF1.14 (IO_L44N_GCLK20_3)
/spartan6/DQ5: IC1.10 (DQ5), UF1.15 (IO_L44P_GCLK21_3)
/spartan6/DQ6: IC1.11 (DQ6), UF1.16 (IO_L43N_GCLK22_3)
/spartan6/DQ7: IC1.13 (DQ7), UF1.8 (IO_L51P_3)
/spartan6/DQ8: IC1.42 (DQ8), UF1.21 (IO_L42N_GCLK24_3)
/spartan6/DQ9: IC1.44 (DQ9), UF1.22 (IO_L42P_GCLK25_3)
/spartan6/DQ10: IC1.45 (DQ10), UF1.23 (IO_L41N_GCLK26_3)
/spartan6/DQ11: IC1.47 (DQ11), UF1.24 (IO_L37N_3)
/spartan6/DQ12: IC1.48 (DQ12), UF1.26 (IO_L41P_3)
/spartan6/DQ13: IC1.50 (DQ13), UF1.27 (IO_L37P_3)
/spartan6/DQ14: IC1.51 (DQ14), UF1.29 (IO_L36N_3)
/spartan6/DQ15: IC1.53 (DQ15), UF1.30 (IO_L36P_3)
/spartan6/DQMH: IC1.39 (DQMH), UF1.17 (IO_L43P_GCLK23_3)
/spartan6/DQML: IC1.15 (DQML), UF1.7 (IO_L51N_3)
/spartan6/FPGA_CLK: UF1.94 (IO_L40N_GCLK10_1), X1.3 (OUT)
/spartan6/F_RXD: UF1.105 (IO_L1P_1); also elsewhere on the board
/spartan6/F_TCK: RF4.1; also elsewhere on the board
/spartan6/F_TDI: RF3.1; also elsewhere on the board
/spartan6/F_TDO: RF7.1; also elsewhere on the board
/spartan6/F_TMS: RF6.1; also elsewhere on the board
/spartan6/F_TXD: UF1.101 (IO_L32N_1); also elsewhere on the board
/spartan6/F_~SD: UF1.34 (IO_L1N_VREF_3); also elsewhere on the board
/spartan6/REBOOT: RF1.2, SW1.1 (A), UF1.37 (PROGRAM_B_2)
/spartan6/TMDS_CLK_N: J1.12 (TMDS_CLOCK_N), R4.1, UF1.133 (IO_L34N_GCLK18_0)
/spartan6/TMDS_CLK_P: J1.10 (TMDS_CLOCK_P), R5.1, UF1.134 (IO_L34P_GCLK19_0)
/spartan6/TMDS_D0_N: J1.9 (TMDS_DATA0_N), R6.1, UF1.118 (IO_L63N_0)
/spartan6/TMDS_D0_P: J1.7 (TMDS_DATA0_P), R7.1, UF1.119 (IO_L63P_0)
/spartan6/TMDS_D1_N: J1.6 (TMDS_DATA1_N), R8.1, UF1.114 (IO_L65N_0)
/spartan6/TMDS_D1_P: J1.4 (TMDS_DATA1_P), R9.1, UF1.115 (IO_L65P_0)
/spartan6/TMDS_D2_N: J1.3 (TMDS_DATA2_N), R10.1, UF1.111 (IO_L66N_0)
/spartan6/TMDS_D2_P: J1.1 (TMDS_DATA2_P), R11.1, UF1.112 (IO_L66P_0)
/spartan6/~CAS: IC1.17 (~CAS~), UF1.5 (IO_L52N_3)
/spartan6/~CS: IC1.19 (~CS~), UF1.1 (IO_L83N_VREF_3)
/spartan6/~RAS: IC1.18 (~RAS~), UF1.2 (IO_L83P_3)
/spartan6/~WE: IC1.16 (~WE~), UF1.6 (IO_L52P_3)
GND: IC1.6 (VSSQ), IC1.12 (VSSQ), IC1.28 (VSS), IC1.41 (VSS), IC1.46 (VSSQ), IC1.52 (VSSQ), IC1.54 (VSS), J1.2 (TMDS_DATA2_SHLD), J1.5 (TMDS_DATA1_SHLD), J1.8 (TMDS_DATA0_SHLD), J1.11 (TMDS_CLOCK_SHLD), J1.SHLD, LVDS1.4, LVDS1.5, LVDS1.6, LVDS1.13, LVDS1.14, RF5.1, RF8.1, SW1.2 (B), UF1.3 (GND), UF1.13 (GND), UF1.25 (GND), UF1.49 (GND), UF1.54 (GND), UF1.60 (IO_L13P_M1_2), UF1.68 (GND), UF1.77 (GND), UF1.91 (GND), UF1.96 (GND), UF1.108 (GND), UF1.113 (GND), UF1.130 (GND), UF1.136 (GND), X1.2 (GND); also elsewhere on the board
unnamed: DF1.2 (A), RF5.2
unnamed: DF2.2 (A), RF8.2
unnamed: RF2.1, UF1.38 (IO_L65N_CSO_B_2)
unnamed: RF3.2, UF1.110 (TDI)
unnamed: RF4.2, UF1.109 (TCK)
unnamed: RF6.2, UF1.107 (TMS)
unnamed: RF7.2, UF1.106 (TDO)
