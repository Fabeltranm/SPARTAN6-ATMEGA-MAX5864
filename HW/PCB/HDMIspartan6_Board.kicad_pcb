# Repository Fabeltranm/SPARTAN6-ATMEGA-MAX5864

File README.md:

# SPARTAN6-ATMEGA-MAX5864

PINOUT

CONECTOR P1

## KiCad design HW/PCB/HDMIspartan6_Board.kicad_pcb

Parts:
TH1, TH2, TH3, TH4, TH5, TH6, TH7, TH8, TH9, TH10, TH11, TH12, TH13, TH14, TH15, TH16, TH17, TH18, TH19, TH20, TH21, TH22, TH23, TH24, TH25, TH26, TH27, TH28, TH29, TH30, TH31, TH32, TH33, TH34, TH35, TH36, TH37, TH38, TH39, TH40, TH41, TH42, TH43, TH44, TH45, TH46, TH47, TH48, TH49, TH50, TH51, TH52, TH53, TH54, TH55, TH56, TH57, TH58, TH59, TH60, TH61, TH62, TH63, TH64, TH65, TH66, TH67, TH68, TH69, TH70, TH71, TH72, TH73, TH74, TH75, TH76, TH77, TH78, TH79, TH80, TH81, TH82, TH83, TH84, TH85, TH86, TH87, TH88, TH89, TH90, TH91, TH92, TH93, TH94, TH95, TH96, TH97, TH98, TH99, TH100, TH101, TH102, TH103, TH104, TH105, TH106, TH107, TH108, TH109, TH110, TH111, TH112, TH113, TH114, TH115, TH116, TH117, TH118, TH119, TH120: CONN_1; 1Pin_12mil_VIA

Connections:
GND: TH1.1, TH2.1, TH3.1, TH4.1, TH5.1, TH6.1, TH7.1, TH8.1, TH9.1, TH10.1, TH11.1, TH12.1, TH13.1, TH14.1, TH15.1, TH16.1, TH17.1, TH18.1, TH19.1, TH20.1, TH21.1, TH22.1, TH23.1, TH24.1, TH25.1, TH26.1, TH27.1, TH28.1, TH29.1, TH30.1, TH31.1, TH32.1, TH33.1, TH34.1, TH35.1, TH36.1, TH37.1, TH38.1, TH39.1, TH40.1, TH41.1, TH42.1, TH43.1, TH44.1, TH45.1, TH46.1, TH47.1, TH48.1, TH49.1, TH50.1, TH51.1, TH52.1, TH53.1, TH54.1, TH55.1, TH56.1, TH57.1, TH58.1, TH59.1, TH60.1, TH61.1, TH62.1, TH63.1, TH64.1, TH65.1, TH66.1, TH67.1, TH68.1, TH69.1, TH70.1, TH71.1, TH72.1, TH73.1, TH74.1, TH75.1, TH76.1, TH77.1, TH78.1, TH79.1, TH80.1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; also elsewhere on the board

Parts:
CF1: 10nF; C_0603
CF2: 10uF; C_0603
CF3: 100nF; C_0603
CF4: 33nF; C_0603
CF5, CF6: 15pF; C_0603
F1: PTS08056V050; R_0805
FT1: FT2232D-REEL; LQFP-48_7x7mm_Pitch0.5mm; DIGIKEY REF 768-1010-1-ND
JMS1: USB-MINI; USB_Mini-B; DIGIKEY REF ED2992TR-ND
LF1: HZ0805D152R-10; R_0805_HandSoldering; DIGIKEY REF 240-2398-1-ND
RF1: 470R; R_0603
RF2, RF3: 27R; R_0603
RF4: 15K; R_0603
RF5: 1K5; R_0603
RF6, RF8: 10k; R_0603
RF7: 10K; R_0603
XF1: CSTCR6M00G53Z-R0; CSTCR6M00G53Z; DIGIKEY REF 490-1218-2-ND

Connections:
+3V3: FT1.14 (VCCIOA), FT1.31 (VCCIOB), RF4.1, RF6.2, RF8.2; also elsewhere on the board
+5V: CF1.1, LF1.1; also elsewhere on the board
/Power/USBVCC: F1.1; also elsewhere on the board
/serial_interface/+5VA: CF2.1, FT1.3 (VCC0), FT1.4 (RESET#), FT1.42 (VCC1), LF1.2, RF1.2, RF7.1
/spartan6/F_RXD: FT1.39 (BDBUS1), RF4.2; also elsewhere on the board
/spartan6/F_TCK: FT1.24 (ADBUS0); also elsewhere on the board
/spartan6/F_TDI: FT1.23 (ADBUS1); also elsewhere on the board
/spartan6/F_TDO: FT1.22 (ADBUS2); also elsewhere on the board
/spartan6/F_TMS: FT1.21 (ADBUS3); also elsewhere on the board
/spartan6/F_TXD: FT1.40 (BDBUS0); also elsewhere on the board
GND: CF1.2, CF2.2, CF3.2, CF4.2, CF5.1, CF6.1, FT1.9 (GND0), FT1.18 (GND1), FT1.25 (GND2), FT1.34 (GND3), FT1.45 (AGND), FT1.47 (TEST), JMS1.5 (GND), JMS1.6 (SH), JMS1.7 (SH), JMS1.8 (SH), JMS1.9 (SH), XF1.2 (GND); also elsewhere on the board
unnamed: CF3.1, FT1.46 (AVVC), RF1.1
unnamed: CF4.1, FT1.6 (3V3OUT)
unnamed: CF5.2, FT1.43 (XTIN), XF1.1
unnamed: CF6.2, FT1.44 (XTOUT), XF1.3
unnamed: F1.2, JMS1.1 (VBUS)
unnamed: FT1.2 (EEDATA), RF7.2
unnamed: FT1.5 (RSTOUT#), RF5.2
unnamed: FT1.7 (USBDP), RF3.2, RF5.1
unnamed: FT1.8 (USBDM), RF2.2
unnamed: FT1.10 (SI/WUA), RF6.1
unnamed: FT1.26 (SI/WUB), RF8.1
unnamed: JMS1.2 (D-), RF2.1
unnamed: JMS1.3 (D+), RF3.1

Parts:
B1: KMR211NG LFS; SW_SPST_KMR2
J1: CONN_02X09; LVDS_SMD
J3: HDMI_A; HDMI_FCI_10029449-11[13]RLF; DIGIKEY REF 10029449-113RLF-ND
LED1, LED2, LED3: LED; LED_0603
P1: CONN_02X20; Pin_Header_Straight_2x20_Pitch2.54mm
P3: CONN_01X03; Pin_Header_Straight_1x03_Pitch2.54mm
R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13: 0; R_0603
RN1: Resistors_array_8; R_Array_Convex_5x1206; DIGIKEY REF CAY17-510JALFTR-ND
RR1, RR3: 4.7k; R_0603
RR2: 330; R_0603
RS1, RS2, RS3, RS4: 68; R_0603
RS6, RS7: 1k; R_0603
U1: XC6SLX9-2TQG144C; LQFP-144_20x20mm_Pitch0.5mm; DIGIKEY REF 122-1745-ND
U6: S25FL064LABNFI041; DFN-8-1EP_4x4mm_Pitch0.8mm; Mouser REF 727-S25FL064LANFI041
XS1: ASV-32.000MHZ-E-T; OSCILLATOR_7x5mm; DIGIKEY REF 535-10082-2-ND
XS2: uSD CARD; Conn_uSDcard; DIGIKEY REF AliExpress:

Connections:
+1V2: U1.19 (VCCINT), U1.28 (VCCINT), U1.52 (VCCINT), U1.89 (VCCINT), U1.128 (VCCINT); also elsewhere on the board
+3V3: J1.1, J1.2, J1.3, P3.1, RN1.5 (C), RN1.10 (C), RR1.1, RR2.1, RR3.1, U1.4 (VCCO_3), U1.18 (VCCO_3), U1.20 (VCCAUX), U1.31 (VCCO_3), U1.36 (VCCAUX), U1.42 (VCCO_2), U1.53 (VCCAUX), U1.63 (VCCO_2), U1.69 (IO_L1N_M0_CMPMISO_2), U1.76 (VCCO_1), U1.86 (VCCO_1), U1.90 (VCCAUX), U1.103 (VCCO_1), U1.122 (VCCO_0), U1.125 (VCCO_0), U1.129 (VCCAUX), U1.135 (VCCO_0), U6.3 (~WP), U6.7 (~HOLD), U6.8 (Vcc), XS1.1 (OE), XS1.4 (VCC), XS2.4 (Vdd); also elsewhere on the board
/ADC_DAC/adCLK: U1.14 (IO_L44N_GCLK20_3); also elsewhere on the board
/ADC_DAC/adCS: U1.121 (IO_L62P_0); also elsewhere on the board
/ADC_DAC/adDA0: U1.10 (IO_L50P_3); also elsewhere on the board
/ADC_DAC/adDA1: U1.9 (IO_L50N_3); also elsewhere on the board
/ADC_DAC/adDA2: U1.8 (IO_L51P_3); also elsewhere on the board
/ADC_DAC/adDA3: U1.7 (IO_L51N_3); also elsewhere on the board
/ADC_DAC/adDA4: U1.6 (IO_L52P_3); also elsewhere on the board
/ADC_DAC/adDA5: U1.5 (IO_L52N_3); also elsewhere on the board
/ADC_DAC/adDA6: U1.1 (IO_L83N_VREF_3); also elsewhere on the board
/ADC_DAC/adDA7: U1.2 (IO_L83P_3); also elsewhere on the board
/ADC_DAC/adDD0: U1.143 (IO_L1N_VREF_0); also elsewhere on the board
/ADC_DAC/adDD1: U1.142 (IO_L2P_0); also elsewhere on the board
/ADC_DAC/adDD2: U1.141 (IO_L2N_0); also elsewhere on the board
/ADC_DAC/adDD3: U1.140 (IO_L3P_0); also elsewhere on the board
/ADC_DAC/adDD4: U1.139 (IO_L3N_0); also elsewhere on the board
/ADC_DAC/adDD5: U1.138 (IO_LP_0); also elsewhere on the board
/ADC_DAC/adDD6: U1.137 (IO_L4N_0); also elsewhere on the board
/ADC_DAC/adDD7: U1.134 (IO_L34P_GCLK19_0); also elsewhere on the board
/ADC_DAC/adDD8: U1.133 (IO_L34N_GCLK18_0); also elsewhere on the board
/ADC_DAC/adDD9: U1.132 (IO_L35P_GCLK17_0); also elsewhere on the board
/ADC_DAC/adMOSI: U1.131 (IO_L35N_GCLK16_0); also elsewhere on the board
/ADC_DAC/adSCK: U1.127 (IO_L36P_GCLK15_0); also elsewhere on the board
/atmega32u4/rst_um: U1.21 (IO_L42N_GCLK24_3); also elsewhere on the board
/atmega32u4/uD0: U1.17 (IO_L43P_GCLK23_3); also elsewhere on the board
/atmega32u4/uD1: U1.16 (IO_L43N_GCLK22_3); also elsewhere on the board
/atmega32u4/uD2: U1.15 (IO_L44P_GCLK21_3); also elsewhere on the board
/atmega32u4/uD3: U1.12 (IO_L49P_3); also elsewhere on the board
/atmega32u4/uDONE: R12.2; also elsewhere on the board
/atmega32u4/uINIT_B: R10.2; also elsewhere on the board
/atmega32u4/uMISO: R4.2; also elsewhere on the board
/atmega32u4/uP0: U1.75 (IO_L74P_1); also elsewhere on the board
/atmega32u4/uP1: R6.2; also elsewhere on the board
/atmega32u4/uP5: R8.2; also elsewhere on the board
/spartan6/CCLK: R6.1, R7.1, U1.70 (IO_L1P_CCLK_2), U6.6 (SCK)
/spartan6/CH1_N: J1.7, U1.40 (IO_L64N_D9_2)
/spartan6/CH1_P: J1.8, U1.41 (IO_L64P_D8_2)
/spartan6/CH2_N: J1.9, U1.43 (IO_L62N_D6_2)
/spartan6/CH2_P: J1.10, U1.44 (IO_L62P_D5_2)
/spartan6/CH3_N: J1.11, U1.45 (IO_L49N_D4_2)
/spartan6/CH3_P: J1.12, U1.46 (IO_L49P_D3_2)
/spartan6/CH4_N: J1.17, U1.50 (IO_L31N_GCLK30_D15_2)
/spartan6/CH4_P: J1.18, U1.51 (IO_L31P_GCLK31_D14_2)
/spartan6/CLK_N: J1.15, U1.47 (IO_L48N_RDW_R_B_VREF_2)
/spartan6/CLK_P: J1.16, U1.48 (IO_L48P_D7_2)
/spartan6/DONE: LED1.2 (A), R12.1, R13.1, RR2.2, U1.71 (DONE_2)
/spartan6/Din: R4.1, R5.1, U1.65 (IO_L3P_D0_DIN_MISO_MISO1_2), U6.2 (MISO)
/spartan6/Dout: R2.2, R3.1, U1.64 (IO_L3N_MOSI_CSI_B_MISO0_2), U6.5 (MOSI)
/spartan6/FPGA_CLK: U1.126 (IO_L36N_GCLK14_0), XS1.3 (OUT)
/spartan6/F_RXD: U1.105 (IO_L1P_1); also elsewhere on the board
/spartan6/F_TCK: RS1.1; also elsewhere on the board
/spartan6/F_TDI: RS2.1; also elsewhere on the board
/spartan6/F_TDO: RS3.1; also elsewhere on the board
/spartan6/F_TMS: RS4.1; also elsewhere on the board
/spartan6/F_TXD: U1.101 (IO_L32N_1); also elsewhere on the board
/spartan6/INIT_B: R10.1, R11.1, RR3.2, U1.39 (IO_L65P_INIT_B_2)
/spartan6/LED1: LED2.1 (K), U1.100 (IO_L33P_1)
/spartan6/LED2: LED3.1 (K); also elsewhere on the board
/spartan6/M1: P3.2, U1.60 (IO_L13P_M1_2)
/spartan6/REBOOT: B1.1 (A), R8.1, R9.1, RR1.2, U1.37 (PROGRAM_B_2)
/spartan6/RpCS: P1.26, U1.74 (IO_L74N_1)
/spartan6/RpDONE: P1.22, R13.2
/spartan6/RpGPIO_04: P1.7, U1.84 (IO_L43N_GCLK4_1)
/spartan6/RpGPIO_05: P1.29, U1.35 (IO_L1P)
/spartan6/RpGPIO_06: P1.31, U1.33 (IO_L2P_3)
/spartan6/RpGPIO_08: P1.24, U1.62 (IO_L12P_D1_MISO2_2)
/spartan6/RpGPIO_12: P1.32, U1.34 (IO_L1N_VREF_3)
/spartan6/RpGPIO_13: P1.33, U1.30 (IO_L36P_3)
/spartan6/RpGPIO_16: P1.36, U1.32 (IO_L2N_3)
/spartan6/RpGPIO_17: P1.11, U1.81 (IO_L46P_1)
/spartan6/RpGPIO_18: P1.12, U1.80 (IO_L46N_1)
/spartan6/RpGPIO_19: P1.35, U1.29 (IO_L36N_3)
/spartan6/RpGPIO_20: P1.38, U1.27 (IO_L37P_3)
/spartan6/RpGPIO_21: P1.40, U1.24 (IO_L37N_3)
/spartan6/RpGPIO_23: P1.16, U1.78 (IO_L47N_1)
/spartan6/RpGPIO_26: P1.37, U1.26 (IO_L41P_3)
/spartan6/RpGPIO_27: P1.13, U1.79 (IO_L47P_1)
/spartan6/RpID_SC: P1.28, U1.61 (IO_L12N_D2_MISO3_2)
/spartan6/RpID_SD: P1.27, U1.59 (IO_L13N_D10_2)
/spartan6/RpINIT_B: P1.15, R11.2
/spartan6/RpMISO: P1.21, R5.2
/spartan6/RpMOSI: P1.19, R3.2
/spartan6/RpPROG: P1.18, R9.2
/spartan6/RpRXD: P1.8, U1.83 (IO_L45P_1)
/spartan6/RpSCK: P1.23, R7.2
/spartan6/RpSCL: P1.5, U1.85 (IO_L43P_GCLK5_1)
/spartan6/RpSDA: P1.3, U1.87 (IO_L42N_GCLK6_1)
/spartan6/RpTXD: P1.10, U1.82 (IO_L45N_1)
/spartan6/TMDS_CLK_N: J3.12 (TMDS_CLOCK_N), RN1.6 (R5), U1.123 (IO_L37N_GCLK12_0)
/spartan6/TMDS_CLK_P: J3.10 (TMDS_CLOCK_P), RN1.7 (R6), U1.124 (IO_L37P_GCLK13_0)
/spartan6/TMDS_D0_N: J3.9 (TMDS_DATA0_N), RN1.4 (R4), U1.111 (IO_L66N_0)
/spartan6/TMDS_D0_P: J3.7 (TMDS_DATA0_P), RN1.3 (R3), U1.112 (IO_L66P_0)
/spartan6/TMDS_D1_N: J3.6 (TMDS_DATA1_N), RN1.8 (R7), U1.114 (IO_L65N_0)
/spartan6/TMDS_D1_P: J3.4 (TMDS_DATA1_P), RN1.9 (R8), U1.115 (IO_L65P_0)
/spartan6/TMDS_D2_N: J3.3 (TMDS_DATA2_N), RN1.2 (R2), U1.116 (IO_L64N_0)
/spartan6/TMDS_D2_P: J3.1 (TMDS_DATA2_P), RN1.1 (R1), U1.117 (IO_L64P_0)
/spartan6/sCS: U1.38 (IO_L65N_CSO_B_2), U6.1 (~CS)
/spartan6/uM0SI: R2.1; also elsewhere on the board
/spartan6/usCS: U1.92 (IO_L41N_GCLK8_1), XS2.2 (CS/DAT3); also elsewhere on the board
/spartan6/usMISO: U1.95 (IO_L40P_GCLK11_1), XS2.7 (DO/DAT0); also elsewhere on the board
/spartan6/usMOSI: U1.93 (IO_L41P_GCLK9_1), XS2.3 (DI/CMD); also elsewhere on the board
/spartan6/usSCK: U1.94 (IO_L40N_GCLK10_1), XS2.5 (CLK); also elsewhere on the board
GND: B1.2 (B), J1.4, J1.5, J1.6, J1.13, J1.14, J3.2 (TMDS_DATA2_SHLD), J3.5 (TMDS_DATA1_SHLD), J3.8 (TMDS_DATA0_SHLD), J3.11 (TMDS_CLOCK_SHLD), J3.SHLD, LED1.1 (K), P1.6, P1.9, P1.14, P1.20, P1.25, P1.30, P1.34, P1.39, P3.3, RS6.1, RS7.1, U1.3 (GND), U1.13 (GND), U1.25 (GND), U1.49 (GND), U1.54 (GND), U1.68 (GND), U1.73 (SUSPEND), U1.77 (GND), U1.91 (GND), U1.96 (GND), U1.108 (GND), U1.113 (GND), U1.130 (GND), U1.136 (GND), U1.144 (IO_L1P_0_HSWAPEN_0), U6.4 (GND), XS1.2 (GND), XS2.6 (GND); also elsewhere on the board
unnamed: LED2.2 (A), RS7.2
unnamed: LED3.2 (A), RS6.2
unnamed: RS1.2, U1.109 (TCK)
unnamed: RS2.2, U1.110 (TDI)
unnamed: RS3.2, U1.106 (TDO)
unnamed: RS4.2, U1.107 (TMS)
VccRpi: P1.2, P1.4; also elsewhere on the board

Notes on the sheet:
+3v3 Rpi
pin 144 gnd for pull_up in soft vcc for pull_up in hw
M[1:0] | Mode CCLK Direction 01 | Master Serial/SPI Output 11 | Slave Serial Input 00 | Master SelectMAP Output -> not implement 10 | Slave SelectMAP Input ->not implement
PROG: CCLK
PROG: SERIAL_OUT
I2C: SCL
I2C: SDA
cambio adDA6 y AdDA7 para conexión en pcb
CMPCS_B_2 Reserved. Leave unconnected or connect High
LVDS
REVISAR LA HUELLA 1206 NO CORRESPONDE LAS MEDIDAS ..ERROR DE KICAD QUE SE DEBE SOLUCIONAR

Parts:
C1: 10uF; C_1210; Voltage 16V
C2: 100nF; C_0603; Voltage 16V
C3: 22uF; C_0805; Voltage 10V
C4: 3.3nF; C_0603; Voltage 16V
C5, C7, C8, C10: 33uF; C_1206
C6, C9: 100n; C_0603
C11, C12, C13, C14, C15, C16, C17, C19, C20, C21, C23, C26, C29, C32, C36, C38: 4.7uF; C_0805; DIGIKEY REF Ceramic X5R ESR < 60mOhm
C18, C22, C24, C25, C27, C28, C30, C31, C33, C34, C35, C37, C39, C40, C41: 0.47uF; C_0402; DIGIKEY REF Ceramic X5R ESR < 60mOhm
C42: 0.1uF; C_0603; DIGIKEY REF Ceramic X5R ESR < 60mOhm
J2: B6B-PH-K-S(LF)(SN); JST_PH_B6B-PH-K_06x2.00mm_Straight
L1: VLS5045EX-2R2N; Inductor_Taiyo-Yuden_NR-50xx; DIGIKEY REF 445-174850-2-ND
P2: CONN_02X03; Pin_Header_Straight_2x03_Pitch2.54mm
PS1: BARREL_JACK; JACK_ALIM
R1: 0R; R_0402
U2: TPS62133RGTR; QFN16; DIGIKEY REF 296-29937-2-ND
U3: ZLDO1117G33TA; SOT-223; DIGIKEY REF ZLDO1117G33DITR-ND
U4: ZLDO1117G12TA; SOT-223; DIGIKEY REF ZLDO1117G12DITR-ND

Connections:
+1V2: C9.1, C10.1, C19.1, C20.1, C21.1, C22.1, C39.1, C40.1, C41.1, U4.2 (OUT), U4.4 (OUTT); also elsewhere on the board
+3V3: C6.1, C7.1, C8.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C42.2, U3.2 (OUT), U3.4 (OUTT), U4.3 (IN); also elsewhere on the board
+5V: C5.1, P2.3, P2.4, U3.3 (IN); also elsewhere on the board
+9V: C1.1, C2.1, J2.5, J2.6, PS1.1, U2.10 (AVIN), U2.11 (PVIN), U2.12 (PVIN), U2.13 (EN)
/Power/PG: R1.1, U2.4 (PG)
/Power/USBVCC: P2.2; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.1, J2.1, J2.2, PS1.2, PS1.3, U2.5 (FB), U2.6 (AGND), U2.8 (DEF), U2.15 (PGND), U2.16 (PGND), U2.17 (TP), U3.1 (GND), U4.1 (GND); also elsewhere on the board
unnamed: C4.1, U2.9 (SS/TR)
unnamed: L1.2, U2.1 (SW), U2.2 (SW), U2.3 (SW)
unnamed: R1.2, U2.7 (FSW)
VDD5V: C3.1, J2.4, L1.1, P2.6, U2.14 (VOS)
VccRpi: P2.1; also elsewhere on the board

Notes on the sheet:
Conector para seleccionar fuente por medio de un jumper. > VDD5V: 5VDC del TPS62133 > +5V: 5VDC de todo el sistema > USBVCC: 5VDC del conector USB > 5vcc of Raspberryí - connector 2x40
Power LCD
Jumper to select operating frequency, see datasheet.
USB decoupling
Vccint decoupling
PCB Decoupling Capacitors Power distribution syystem Xilinx UG393 (v1.3) October 17, 2012
Vccaux decoupling
Vcco B4 decoupling
Vcco B2 decoupling
Vcco B1 decoupling
Vcco B0 decoupling
SPI MEMORY decoupling

Parts:
C50, C51, C52, C56: 4.7uF; C_0805; DIGIKEY REF Ceramic X5R ESR < 60mOhm
C53, C54, C55, C57: 0.47uF; C_0402; DIGIKEY REF Ceramic X5R ESR < 60mOhm
CA1, CA2, CA3: 330nF; C_0402
P4: CONN_02X05; Pin_Header_Straight_2x05_Pitch2.54mm
U5: MAX5864; GSG-QFN48-7; DIGIKEY REF MAX5864ETM+-ND

Connections:
+3V3: C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, P4.2, U5.2 (VDD), U5.8 (VDD), U5.11 (VDD), U5.18 (OVDD), U5.33 (VDD), U5.39 (VDD), U5.43 (VDD), U5.46 (REFIN); also elsewhere on the board
/ADC_DAC/COM: CA1.1, U5.47 (COM)
/ADC_DAC/IA+: P4.8, U5.3 (IA+)
/ADC_DAC/IA-: P4.7, U5.4 (IA-)
/ADC_DAC/ID+: P4.6, U5.45 (ID+)
/ADC_DAC/ID-: P4.5, U5.44 (ID-)
/ADC_DAC/QA+: P4.9, U5.10 (QA+)
/ADC_DAC/QA-: P4.10, U5.9 (QA-)
/ADC_DAC/QD+: P4.3, U5.40 (QD+)
/ADC_DAC/QD-: P4.4, U5.41 (QD-)
/ADC_DAC/REFN: CA2.1, U5.48 (REFN)
/ADC_DAC/REFP: CA3.1, U5.1 (REFP)
/ADC_DAC/adCLK: U5.6 (CLK); also elsewhere on the board
/ADC_DAC/adCS: U5.36 (CS); also elsewhere on the board
/ADC_DAC/adDA0: U5.13 (DA0); also elsewhere on the board
/ADC_DAC/adDA1: U5.14 (DA1); also elsewhere on the board
/ADC_DAC/adDA2: U5.15 (DA2); also elsewhere on the board
/ADC_DAC/adDA3: U5.16 (DA3); also elsewhere on the board
/ADC_DAC/adDA4: U5.19 (DA4); also elsewhere on the board
/ADC_DAC/adDA5: U5.20 (DA5); also elsewhere on the board
/ADC_DAC/adDA6: U5.21 (DA6); also elsewhere on the board
/ADC_DAC/adDA7: U5.22 (DA7); also elsewhere on the board
/ADC_DAC/adDD0: U5.23 (DD0); also elsewhere on the board
/ADC_DAC/adDD1: U5.24 (DD1); also elsewhere on the board
/ADC_DAC/adDD2: U5.25 (DD2); also elsewhere on the board
/ADC_DAC/adDD3: U5.26 (DD3); also elsewhere on the board
/ADC_DAC/adDD4: U5.27 (DD4); also elsewhere on the board
/ADC_DAC/adDD5: U5.28 (DD5); also elsewhere on the board
/ADC_DAC/adDD6: U5.29 (DD6); also elsewhere on the board
/ADC_DAC/adDD7: U5.30 (DD7); also elsewhere on the board
/ADC_DAC/adDD8: U5.31 (DD8); also elsewhere on the board
/ADC_DAC/adDD9: U5.32 (DD9); also elsewhere on the board
/ADC_DAC/adMOSI: U5.34 (DIN); also elsewhere on the board
/ADC_DAC/adSCK: U5.35 (SCLK); also elsewhere on the board
GND: C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, CA1.2, CA2.2, CA3.2, P4.1, U5.0 (EP), U5.5 (GND), U5.7 (GND), U5.12 (GND), U5.17 (OGND), U5.37 (GND), U5.42 (GND); also elsewhere on the board

Notes on the sheet:
Vcc 2,8,43 decoupling
Vcc 18 decoupling
